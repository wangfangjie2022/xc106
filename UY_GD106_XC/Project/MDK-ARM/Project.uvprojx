# Keil uVision project Project.uvprojx, settings and files
target GD32450I_EVAL (ARM-ADS)
  device: GD32F405RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F405,__FPU_USED=1,__FPU_PRESENT=1
  c misc: --gnu -Dlittle_endian
  c include: ..\;..\..\Hardware\4G\CloudServer;..\..\Hardware\4G\LTE4G_Cat1;..\..\Hardware\4G\utils;..\..\Hardware\OV2640;..\..\Hardware\RTT;..\..\Hardware\SRAM;..\..\Library\CMSIS\GD\GD32F4xx\Include;..\..\Library\CMSIS;..\..\Library\GD32F4xx_standard_peripheral\Include;..\MDK-ARM;..\..\Hardware\FLASH;..\..\Hardware\TIMER;..\..\Hardware\LED;..\..\Hardware\MODBUS;..\..\Hardware\WATCHDOG;..\..\Hardware\SDIO;..\..\Hardware\DCMI;..\..\Hardware\OV2640\OV2640;..\..\Hardware\OV2640;..\..\Hardware\I2C;..\..\Hardware\APP;..\..\Hardware\SAOMA;..\..\UCOSII\CONFIG;..\..\UCOSII\CORE;..\..\UCOSII\PORT;..\..\Hardware\fat_fs;..\..\Hardware\fat_fs\option;..\..\Hardware\RTC;..\..\Hardware\WTNX;..\..\Hardware\GPS
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: systick.c gd32f4xx_it.c sys.c main.c debug.c Version.c delay.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../../Library/Utilities/: gd32f450i_eval.c
  group Startup
    ../../Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
  group Doc
    ../: readme.txt
  group HARDWARE
    ../../Hardware/OV2640/: picture.c ov2640.c
    ../../Hardware/SRAM/: exmc_sdram.c
    ../../Hardware/FLASH/: flash_e2prom.c
    ../../Hardware/TIMER/: timer1.c
    ../../Hardware/LED/: led.c
    ../../Hardware/MODBUS/: Modbus_Base.c
    ../../Hardware/WATCHDOG/: watchdog.c
    ../../Hardware/SDIO/: sdcard.c
    ../../Hardware/DCMI/: dcmi.c
    ../../Hardware/I2C/: sccb.c soft_iic.c
    ../../Hardware/SAOMA/: saoma.c
    ../../Hardware/RTC/: rtc.c
    ../../Hardware/WTNX/: wtn.c
    ../../Hardware/GPS/: gps.c
  group 4G
    ../../Hardware/4G/CloudServer/: CloudServerConnect.c MQTTcontent.c
    ../../Hardware/4G/LTE4G_Cat1/: at_module.c at_parser.c at_port.c cat1_port.c network.c queue.c
    ../../Hardware/4G/utils/: cJSON.c cstdlib.c utils_aes.c utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../../Hardware/MODBUS/: crc.c
  group RTT
    ../../Hardware/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group FATFS
    ../../Hardware/fat_fs/: diskio.c ff.c fattester.c
    ../../Hardware/fat_fs/option/: cc936.c
  group APP
    ../../Hardware/APP/: camera.c upload_file.c
  group UCOSII-CORE
    ../../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../../UCOSII/CONFIG/: includes.h os_cfg.h
software components: CMSIS:CORE 5.2.0
